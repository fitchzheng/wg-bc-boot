# Keil uVision project template.uvprojx, settings and files
target template_Debug (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: HC32F334KATI HDSC
  pack: HDSC.HC32F334.1.0.0
  cpu: IROM1(0x00000000,0x20000) IROM2(0x03000000,0x1800) IRAM1(0x1FFFC000,0x8000) IRAM2(0x200F0000,0x1000) CPUTYPE("Cortex-M4") FPU2 CLOCK(8000000) ESEL ELITTLE
  output: HC32F334KATI +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: __DEBUG,HC32F334,USE_DDL_DRIVER,__FPU_PRESENT,__TARGET_FPU_VFP,ARM_MATH_CM4
  c include: .\bsp;.\cmsis\Include;.\hc32_ll_driver\inc;..\xh_keil;.\cmsis\Device\HDSC\hc32f3xx\Include;..\section;..\user\L1;..\user\L2;..\user\L3
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x5000
  memory RVCT5: ROM 0x3000000 size 0x1800
  memory RVCT9: RAM 0x1fffc000 size 0x8000
  memory RVCT10: RAM 0x200f0000 size 0x1000
  scatter file: .\Project.sct
  link misc: --keep=*Handler
  group cmsis
    ./: startup_hc32f334.s system_hc32f334.c
  group source
    ./: main.c
  group bsp
    ./bsp/: bsp_dma.c bsp_flash.c bsp_can.c bsp_gpio.c bsp_usart.c ev_hc32f334_lqfp64.c bsp_init.c
  group driver
    ./hc32_ll_driver/src/: hc32_ll.c hc32_ll_adc.c hc32_ll_aos.c hc32_ll_clk.c hc32_ll_cmp.c hc32_ll_crc.c hc32_ll_ctc.c hc32_ll_dac.c hc32_ll_dbgc.c hc32_ll_dma.c hc32_ll_efm.c hc32_ll_emb.c hc32_ll_event_port.c hc32_ll_fcg.c hc32_ll_fcm.c hc32_ll_gpio.c hc32_ll_hrpwm.c hc32_ll_i2c.c hc32_ll_icg.c hc32_ll_interrupts.c hc32_ll_mcan.c hc32_ll_mpu.c hc32_ll_pla.c hc32_ll_pwc.c hc32_ll_rmu.c hc32_ll_rtc.c hc32_ll_spi.c hc32_ll_sram.c hc32_ll_swdt.c hc32_ll_tmr0.c hc32_ll_tmr4.c hc32_ll_tmr6.c hc32_ll_tmra.c hc32_ll_usart.c hc32_ll_utility.c hc32_ll_wdt.c
  group section
    ../section/: section.c
  group L1
    ../user/L1/: led.c data_com.c
  group L2
    ../user/L2/: led_ctrl.c
  group L3
    ../user/L3/: gpio.c flash.c ymodem.c can_ota.c wg_com_v2.c
  group DSP
    ./: arm_cortexM4l_math.lib
target HC32F334KIATI_Bootloader (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: HC32F334KATI HDSC
  pack: HDSC.HC32F334.1.0.0
  cpu: as above
  output: WG-BC1500M_BOOT_20260615 +hex
  AfterMake: fromelf  --bin -o "$L@L.bin" "#L"
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: HC32F334,USE_DDL_DRIVER,__FPU_PRESENT,__TARGET_FPU_VFP,ARM_MATH_CM4
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x5000
  memory RVCT5: ROM 0x3000000 size 0x1800
  memory RVCT9: RAM 0x1fffc000 size 0x8000
  memory RVCT10: RAM 0x200f0000 size 0x1000
  scatter file: .\Project.sct
  link misc: --keep=*Handler
